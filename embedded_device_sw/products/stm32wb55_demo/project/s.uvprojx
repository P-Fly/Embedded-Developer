# Keil uVision project s.uvprojx, settings and files
target stm32wb55 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32WB55RGVx STMicroelectronics
  pack: Keil.STM32WBxx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00040000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: stm32wb55_demo +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CORE_CM4,STM32WB,STM32WB55xx,USE_HAL_DRIVER,__ASSERT_MSG
  c include: ..\conf;..\include;..\..\..\bsp\arch\arm\cortex_m\cmsis\core\include;..\..\..\bsp\arch\arm\cortex_m\cmsis\device\stm32wb55\include;..\..\..\bsp\drivers\include;..\..\..\bsp\drivers\lib\stm32wbxx\include;..\..\..\framework\include;..\..\..\middlewares\external\freertos\CMSIS_RTOS;..\..\..\middlewares\external\freertos\include;..\..\..\middlewares\external\freertos\portable\RVDS\ARM_CM4F;..\..\..\middlewares\external\cunit\include;..\..\..\utils\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
  scatter file: ..\..\..\bsp\arch\arm\cortex_m\cmsis\device\stm32wb55\src\arm\linker\stm32wb55xx_flash_cm4.sct
  link misc: --diag_suppress L6314W,L6330W
  group bsp\arch\arm\cortex_m\boot\stm32wb55
    ../../../bsp/arch/arm/cortex_m/cmsis/device/stm32wb55/src/: system_stm32wbxx.c
    ../../../bsp/arch/arm/cortex_m/cmsis/device/stm32wb55/src/arm/: startup_stm32wb55xx_cm4.s
  group bsp\drivers\stm32wbxx
    ../../../bsp/drivers/src/stm32wbxx/: uart.c crc.c
  group bsp\drivers\lib\stm32wbxx
    ../../../bsp/drivers/lib/stm32wbxx/src/: stm32wbxx_hal.c stm32wbxx_hal_adc.c stm32wbxx_hal_adc_ex.c stm32wbxx_hal_comp.c stm32wbxx_hal_cortex.c stm32wbxx_hal_crc.c stm32wbxx_hal_crc_ex.c stm32wbxx_hal_cryp.c stm32wbxx_hal_cryp_ex.c stm32wbxx_hal_dma.c stm32wbxx_hal_dma_ex.c stm32wbxx_hal_exti.c stm32wbxx_hal_flash.c stm32wbxx_hal_flash_ex.c stm32wbxx_hal_gpio.c stm32wbxx_hal_hsem.c stm32wbxx_hal_i2c.c stm32wbxx_hal_i2c_ex.c stm32wbxx_hal_ipcc.c stm32wbxx_hal_irda.c stm32wbxx_hal_iwdg.c stm32wbxx_hal_lcd.c stm32wbxx_hal_lptim.c stm32wbxx_hal_pcd.c stm32wbxx_hal_pcd_ex.c stm32wbxx_hal_pka.c stm32wbxx_hal_pwr.c stm32wbxx_hal_pwr_ex.c stm32wbxx_hal_qspi.c stm32wbxx_hal_rcc.c stm32wbxx_hal_rcc_ex.c stm32wbxx_hal_rng.c stm32wbxx_hal_rtc.c stm32wbxx_hal_rtc_ex.c stm32wbxx_hal_sai.c stm32wbxx_hal_sai_ex.c stm32wbxx_hal_smartcard.c stm32wbxx_hal_smartcard_ex.c stm32wbxx_hal_smbus.c stm32wbxx_hal_spi.c stm32wbxx_hal_spi_ex.c stm32wbxx_hal_tim.c stm32wbxx_hal_tim_ex.c stm32wbxx_hal_tsc.c stm32wbxx_hal_uart.c stm32wbxx_hal_uart_ex.c stm32wbxx_hal_usart.c stm32wbxx_hal_usart_ex.c stm32wbxx_hal_wwdg.c stm32wbxx_ll_adc.c stm32wbxx_ll_comp.c stm32wbxx_ll_crc.c stm32wbxx_ll_crs.c stm32wbxx_ll_dma.c stm32wbxx_ll_exti.c stm32wbxx_ll_gpio.c stm32wbxx_ll_i2c.c stm32wbxx_ll_lptim.c stm32wbxx_ll_lpuart.c stm32wbxx_ll_pka.c stm32wbxx_ll_pwr.c stm32wbxx_ll_rcc.c stm32wbxx_ll_rng.c stm32wbxx_ll_rtc.c stm32wbxx_ll_spi.c stm32wbxx_ll_tim.c stm32wbxx_ll_usart.c stm32wbxx_ll_usb.c stm32wbxx_ll_utils.c
  group middlewares\external\freertos
    ../../../middlewares/external/freertos/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../middlewares/external/freertos/portable/MemMang/: heap_4.c
    ../../../middlewares/external/freertos/portable/RVDS/ARM_CM4F/: port.c
    ../../../middlewares/external/freertos/CMSIS_RTOS/: cmsis_os.c
  group middlewares\external\cunit
    ../../../middlewares/external/cunit/src/framework/: CUError.c MyMem.c TestDB.c TestRun.c Util.c
    ../../../middlewares/external/cunit/src/console/: Console.c
    ../../../middlewares/external/cunit/src/basic/: Basic.c
  group framework\base
    ../../../framework/src/base/: object.c init.c
  group framework\tunit
    ../../../framework/src/tunit/: tunit.c
  group utils
    ../../../utils/src/: assert.c trace.c
  group tcase
    ../../../tcase/utils/: tcase_ring_buff.c
    ../../../tcase/driver/: tcase_crc.c
  group products
    ../src/: hardware.c
