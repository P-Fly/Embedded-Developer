# Keil uVision project s.uvprojx, settings and files
target lm3S9b96 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LM3S9B96 Texas Instruments
  pack: Keil.LM3S_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00018000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: lm3s9b96_demo +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CORE_CM3,__ASSERT_MSG
  c include: ..\conf;..\include;..\..\..\bsp\arch\arm\cortex_m\cmsis\core\include;..\..\..\bsp\arch\arm\cortex_m\cmsis\device\lm3S9b96\include;..\..\..\bsp\drivers\include;..\..\..\bsp\drivers\lib\lm3s9xxx;..\..\..\framework\include;..\..\..\middlewares\external\freertos\CMSIS_RTOS_V2;..\..\..\middlewares\external\freertos\include;..\..\..\middlewares\external\freertos\portable\RVDS\ARM_CM3;..\..\..\middlewares\external\cunit\include;..\..\..\utils\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  link misc: --diag_suppress L6314W,L6330W
  group bsp\arch\arm\cortex_m\boot\lm3s9b96
    ../../../bsp/arch/arm/cortex_m/cmsis/device/lm3S9b96/src/arm/: Startup.s
  group bsp\drivers\lib\lm3s9xxx
    ../../../bsp/drivers/lib/lm3s9xxx/driverlib/: adc.c can.c comp.c cpu.c epi.c ethernet.c flash.c gpio.c hibernate.c i2c.c i2s.c interrupt.c mpu.c pwm.c qei.c ssi.c sysctl.c systick.c timer.c uart.c udma.c usb.c watchdog.c
  group middlewares\external\freertos
    ../../../middlewares/external/freertos/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../middlewares/external/freertos/portable/MemMang/: heap_4.c
    ../../../middlewares/external/freertos/portable/RVDS/ARM_CM3/: port.c
    ../../../middlewares/external/freertos/CMSIS_RTOS_V2/: cmsis_os2.c
    ../../../middlewares/external/freertos/hooks/: hooks.c
  group middlewares\external\cunit
    ../../../middlewares/external/cunit/src/framework/: CUError.c MyMem.c TestDB.c TestRun.c Util.c
    ../../../middlewares/external/cunit/src/console/: Console.c
    ../../../middlewares/external/cunit/src/basic/: Basic.c
  group framework\base
    ../../../framework/src/base/: object.c init.c message.c service.c
  group framework\tunit
    ../../../framework/src/tunit/: tunit.c
  group utils
    ../../../utils/src/: assert.c trace.c
  group tcase
    ../../../tcase/framework/: tcase_service.c
    ../../../tcase/utils/: tcase_ring_buff.c
    ../../../tcase/driver/: tcase_crc.c
